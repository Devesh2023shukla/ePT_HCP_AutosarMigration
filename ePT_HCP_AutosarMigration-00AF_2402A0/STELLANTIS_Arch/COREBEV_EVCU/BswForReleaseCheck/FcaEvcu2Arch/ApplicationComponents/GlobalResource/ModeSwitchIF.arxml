<?xml version="1.0" encoding="utf-8"?>
<!--Created with SystemDesk 5.1.3.11821-->
<AUTOSAR xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xmlns="http://autosar.org/schema/r4.0" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-2-2.xsd" />